<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_awu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\..\USER\Adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\ctrl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\Filter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\uart.c</name>
    </file>
  </group>
</project>


